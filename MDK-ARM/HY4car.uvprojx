# Keil uVision project HY4car.uvprojx, settings and files
target HY4car (5060960::V5.06 update 7 (build 960)::.\ARM506)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: HY4car +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Core/Application/OLED;../Core/Application/MPU6050;../Core/Application
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Inc/: main.h
    ../Core/Src/: main.c gpio.c i2c.c spi.c tim.c stm32f1xx_hal_msp.c usart.c stm32f1xx_it.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Application
    ../Core/Application/: Buzzer.c Buzzer.h Delay.c Delay.h LED.c LED.h MG513.c MG513.h MY1690.c MY1690.h NRF24L01.c NRF24L01.h Servos.c Servos.h SevenWay.c SevenWay.h Encoder.c Encoder.h PID.c PID.h action.c ringbuffer.c button.c GlobalLocalization.c astar.c translate_route_cmd.c imu901.c plan.c shovel_strategy.c
  group OLED
    ../Core/Application/OLED/: OLED.c OLED.h OLED_Data.h OLED_Data_ASCII.c OLED_Data_Hanzi.c OLED_Data_Image.c OLED_Patch_byAdam.c
software components: CMSIS:CORE 6.1.1
